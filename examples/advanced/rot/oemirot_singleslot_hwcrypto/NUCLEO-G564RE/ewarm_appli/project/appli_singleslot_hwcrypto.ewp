# IAR project appli_singleslot_hwcrypto.ewp, settings and files
configuration release (ARM, debug)
  General.CoreVariant: 61
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32G564RE ST STM32G564RE
  General.FPU2: 6
  ICCARM.CCDefines: STM32G564xx; USE_TRACE=0; _RTE_
  ICCARM.IExtraOptions: --enable_restrict
  ICCARM.PreInclude: ../../appli/fw_update_pre_include_global.h
  ICCARM.CCIncludePath2: ../../../../../../../arch/cmsis/CMSIS/Core/Include; ../../../../../../../middleware/mbedtls/configs; ../../../../../../../middleware/mbedtls/include; ../../../../../../../middleware/mbedtls/include/mbedtls; ../../../../../../../middleware/mbedtls/include/psa; ../../../../../../../middleware/mbedtls/library; ../../../../../../../middleware/mcuboot/boot/bootutil/include; ../../../../../../../middleware/mcuboot/boot/bootutil/include/bootutil; ../../../../../../../middleware/mcuboot/boot/bootutil/include/bootutil/crypto; ../../../../../../../middleware/mcuboot/boot/bootutil/src; ../../../../../../../middleware/mcuboot/platform_common; ../../../../../../../middleware/stfcf/mbedtls_alt/include/common; ../../../../../../../middleware/stfcf/mbedtls_alt/include/hal; ../../../../../../../stm32g5xx_dfp/Include; ../../../../../../../stm32g5xx_drivers/hal; ../../../../../../../stm32g5xx_drivers/ll; ../../../../../../../stm32g5xx_drivers/timebases; ../../../../../../../utilities/basic_stdio; ../../../../../../../utilities/basic_stdio/interface_io; ../../appli; ../../appli/generated/middleware/stfcf; ../../appli/generated/hal; ../../appli/generated/utilities/basic_stdio; ../../appli/user_modifiable/_release_IAR_NUCLEO-G564RE
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: STM32G564xx; _RTE_
  AARM.AUserIncludes: ../../../../../../../arch/cmsis/CMSIS/Core/Include; ../../../../../../../stm32g5xx_dfp/Include; ../../../../../../../stm32g5xx_drivers/hal; ../../../../../../../stm32g5xx_drivers/ll; ../../../../../../../stm32g5xx_drivers/timebases; ../../../../../../../utilities/basic_stdio; ../../../../../../../utilities/basic_stdio/interface_io; ../../appli; ../../appli/generated/hal; ../../appli/generated/utilities/basic_stdio; ../../appli/user_modifiable/_release_IAR_NUCLEO-G564RE
  OBJCOPY.OOCOutputFile: ..\..\bin\appli.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ../../appli/user_modifiable/Device/STM32G564RET3/stm32g564xe_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group appli
    ../../appli/: appli_flash_layout.h com.c com.h common.c common.h data.c data.h Driver_Common.h Driver_Flash.h fw_update_app.c fw_update_app.h low_level_device.c low_level_flash.c low_level_flash.h main.c main.h ymodem.c ymodem.h
  group appli/generated/hal
    ../../appli/generated/hal/: mx_cortex_mpu.c mx_cortex_mpu.h mx_cortex_nvic.c mx_cortex_nvic.h mx_crc.c mx_crc.h mx_def.h mx_flash.c mx_flash.h mx_hal_def.h mx_icache.c mx_icache.h mx_rcc.c mx_rcc.h mx_system.c mx_system.h mx_usart2.c mx_usart2.h stm32g5xx_hal_conf.h
  group appli/generated/utilities/basic_stdio
    ../../appli/generated/utilities/basic_stdio/: mx_basic_stdio_app.c mx_basic_stdio_app.h
  group appli/user_modifiable/Device/STM32G564RET3
    ../../appli/user_modifiable/Device/STM32G564RET3/: startup_stm32g564xx.c system_stm32g5xx.c
  group MCUboot shared RAM support
    ../../appli/: mcuboot_shared_platform.c
    ../../shared/: mcuboot_shared_data.h
  group LED blink timer
    ../../appli/: appli_led_timer.c appli_led_timer.h
  group Hardware crypto support
    ../../appli/: low_level_rng.c low_level_rng.h
    ../../appli/generated/hal/: mx_hash.c mx_hash.h mx_pka.c mx_pka.h mx_rng.c mx_rng.h mx_saes.c mx_saes.h
    ../../../../../../../stm32g5xx_drivers/hal/: stm32g5xx_hal_aes.c stm32g5xx_hal_hash.c stm32g5xx_hal_pka.c stm32g5xx_hal_rng.c
  group MCUboot and mbedTLS configuration
    ../../appli/: boot_hal_cfg.h boot_hal_hash_ref.h boot_hal_imagevalid.h boot_hal_utils.h flash_layout.h fw_update_pre_include_global.h low_level_obkeys.h low_level_security_config.h mcuboot_config.h region_defs.h
    ../../appli/generated/middleware/stfcf/: mx_mbedtls_alt_config.h mx_mbedtls_config.h mx_stfcf_config.h
  group middleware/mbedtls/include/mbedtls
    ../../../../../../../middleware/mbedtls/include/mbedtls/: aes.h aria.h asn1.h asn1write.h base64.h camellia.h ccm.h chacha20.h chachapoly.h check_config.h cmac.h ctr_drbg.h debug.h des.h dhm.h ecdh.h ecdsa.h ecjpake.h ecp.h entropy.h gcm.h mbedtls_config.h memory_buffer_alloc.h rsa.h sha256.h version.h
  group middleware/mbedtls/include/psa
    ../../../../../../../middleware/mbedtls/include/psa/: crypto.h crypto_adjust_config_dependencies.h crypto_platform.h crypto_types.h crypto_values.h
  group middleware/mbedtls/library
    ../../../../../../../middleware/mbedtls/library/: aes.c aria.c asn1parse.c asn1write.c base64.c bignum.c bignum_core.c bignum_core.h bignum_internal.h bn_mul.h camellia.c ccm.c chacha20.c chachapoly.c cipher.c cipher_wrap.c cmac.c constant_time.c constant_time_internal.h ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c hkdf.c hmac_drbg.c md.c md5.c memory_buffer_alloc.c nist_kw.c oid.c pem.c pk.c pk_ecc.c pk_wrap.c pkcs12.c pkcs5.c pkparse.c pkwrite.c platform.c platform_util.c poly1305.c psa_crypto.c psa_crypto_aead.c psa_crypto_cipher.c psa_crypto_client.c psa_crypto_driver_wrappers_no_static.c psa_crypto_driver_wrappers_no_static.h psa_crypto_ecp.c psa_crypto_ffdh.c psa_crypto_hash.c psa_crypto_mac.c psa_crypto_pake.c psa_crypto_random.c psa_crypto_random.h psa_crypto_rsa.c psa_crypto_slot_management.c psa_crypto_slot_management.h psa_its_file.c psa_util.c psa_util_internal.h ripemd160.c rsa.c rsa_alt_helpers.c rsa_alt_helpers.h sha1.c sha256.c sha3.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_client.c ssl_cookie.c ssl_debug_helpers_generated.c ssl_msg.c ssl_ticket.c ssl_tls.c ssl_tls12_client.c ssl_tls12_server.c ssl_tls13_client.c ssl_tls13_generic.c ssl_tls13_keys.c ssl_tls13_server.c threading.c timing.c version.c version_features.c x509.c x509_create.c x509_crl.c x509_crt.c x509_csr.c x509write.c x509write_crt.c x509write_csr.c
  group middleware/mcuboot
    ../../../../../../../middleware/mcuboot/: LICENSE.md README.md ST_Release_Notes.md SW_Security_Level.md
  group middleware/mcuboot/boot/bootutil/include/bootutil
    ../../../../../../../middleware/mcuboot/boot/bootutil/include/bootutil/: boot_hooks.h boot_public_hooks.h boot_record.h boot_status.h bootutil.h bootutil_log.h bootutil_public.h caps.h enc_key.h enc_key_public.h fault_injection_hardening.h fault_injection_hardening_delay_rng.h ignore.h image.h mcuboot_status.h ramload.h security_cnt.h sign_key.h
  group middleware/mcuboot/boot/bootutil/include/bootutil/crypto
    ../../../../../../../middleware/mcuboot/boot/bootutil/include/bootutil/crypto/: aes_ctr.h common.h ecdh_p256.h ecdsa.h hmac_sha256.h sha.h
  group middleware/mcuboot/boot/bootutil/src
    ../../../../../../../middleware/mcuboot/boot/bootutil/src/: bootutil_misc.c bootutil_misc.h bootutil_priv.h bootutil_public.c caps.c encrypted.c fault_injection_hardening.c fault_injection_hardening_delay_rng_mbedtls.c image_ecdsa.c image_validate.c loader.c swap_misc.c swap_move.c swap_priv.h swap_scratch.c tlv.c
  group middleware/mcuboot/docs
    ../../../../../../../middleware/mcuboot/docs/: design.md ecdsa.md encrypted_images.md index.md release-notes.md
  group middleware/mcuboot/platform_common
    ../../../../../../../middleware/mcuboot/platform_common/: boot_hal.h cryptoboot_hal.h Driver_Common.h Driver_Flash.h fih.h flash_map.c flash_map.h flash_map_backend.h flash_map_extended.c flash_map_legacy.c mcuboot_logging.h plat_defs.h plat_nv_counters.h security_cnt.c sysflash.h
  group middleware/stfcf
    ../../../../../../../middleware/stfcf/: LICENSE.md README.md Release_Notes.md SW_Security_Level.md
  group middleware/stfcf/mbedtls_alt/include/common
    ../../../../../../../middleware/stfcf/mbedtls_alt/include/common/: aes_alt.h ecp_alt.h entropy_hardware_alt.h sha256_alt.h sha512_alt.h
  group middleware/stfcf/mbedtls_alt/include/hal
    ../../../../../../../middleware/stfcf/mbedtls_alt/include/hal/: hal_aes_alt.h hal_ecp_alt.h hal_sha256_alt.h hal_sha512_alt.h
  group middleware/stfcf/mbedtls_alt/source/hal
    ../../../../../../../middleware/stfcf/mbedtls_alt/source/hal/: aes_aes_alt.c ecdh_alt.c ecdsa_alt.c ecp_alt.c ecp_curves_alt.c entropy_hardware_alt.c sha256_alt.c sha512_alt.c
  group stm32g5xx_dfp
    ../../../../../../../stm32g5xx_dfp/: README.md
  group stm32g5xx_dfp/Include
    ../../../../../../../stm32g5xx_dfp/Include/: partition_stm32g5xx.h stm32g5xx.h
  group stm32g5xx_drivers
    ../../../../../../../stm32g5xx_drivers/: LICENSE.md README.md Release_Notes.md SW_Security_Level.md
  group stm32g5xx_drivers/doc
    ../../../../../../../stm32g5xx_drivers/doc/: STMicroelectronics.stm32g5xx_hal_drivers_dependencies.md
  group stm32g5xx_drivers/hal
    ../../../../../../../stm32g5xx_drivers/hal/: stm32_hal.h stm32g5xx_hal.c stm32g5xx_hal.h stm32g5xx_hal_cortex.c stm32g5xx_hal_cortex.h stm32g5xx_hal_crc.c stm32g5xx_hal_crc.h stm32g5xx_hal_def.h stm32g5xx_hal_dma.c stm32g5xx_hal_dma.h stm32g5xx_hal_flash.c stm32g5xx_hal_flash.h stm32g5xx_hal_flash_itf.c stm32g5xx_hal_flash_itf.h stm32g5xx_hal_gpio.c stm32g5xx_hal_gpio.h stm32g5xx_hal_icache.c stm32g5xx_hal_icache.h stm32g5xx_hal_pwr.c stm32g5xx_hal_pwr.h stm32g5xx_hal_q.c stm32g5xx_hal_q.h stm32g5xx_hal_rcc.c stm32g5xx_hal_rcc.h stm32g5xx_hal_uart.c stm32g5xx_hal_uart.h
  group stm32g5xx_drivers/ll
    ../../../../../../../stm32g5xx_drivers/ll/: stm32g5xx_ll_bus.h stm32g5xx_ll_crc.h stm32g5xx_ll_dma.h stm32g5xx_ll_exti.h stm32g5xx_ll_flash.h stm32g5xx_ll_gpio.h stm32g5xx_ll_icache.h stm32g5xx_ll_pwr.h stm32g5xx_ll_rcc.h stm32g5xx_ll_usart.h stm32g5xx_ll_utils.h
  group utilities/basic_stdio
    ../../../../../../../utilities/basic_stdio/: basic_stdio_core.c basic_stdio_core.h README.md SW_Security_Level.md
  group utilities/basic_stdio/interface_io
    ../../../../../../../utilities/basic_stdio/interface_io/: basic_stdio_itf_io.h basic_stdio_itfio_uart.c
  group utilities/rot_provisioning
    ../../../../../../../utilities/rot_provisioning/: LICENSE.md README.md Release_Notes.md SW_Security_Level.md
